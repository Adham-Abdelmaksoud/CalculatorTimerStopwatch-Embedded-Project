<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Final.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\IAR Codes\Lab9\lab9.ewp</path>
    </project>
    <batchBuild />
</workspace>
